<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimplLCD_SRAM _NORFL.ewp</path>
  </project>
  <batchBuild/>
</workspace>
