# IAR project SimplLCD_SRAM _NORFL.ewp, settings and files
configuration SWM320 (ARM, debug)
  General.OGChipSelectEditMenu: SWM320xE Synwit SWM320xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver; .\APP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: SimplLCD_SRAM _NORFL.srec
  ILINK.IlinkOutputFile: SimplLCD_SRAM _NORFL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
    ./APP/: ugui.c
  group CSL\StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c SWM320_norflash.c SWM320_sdram.c SWM320_sram.c
  group CSL\CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM320.s
