# Keil uVision project CANopen.uvprojx, settings and files
target SWM320 (ARM-ADS)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: CANopen
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\CANopen
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
    ./APP/: TestSlave.c CAN_SWM320.c timers_SWM320.c
  group CANopen
    ./APP/CANopen/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer_canfestival.c
  group CSL\StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c
  group CSL\CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
